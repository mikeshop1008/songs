# Keil uVision project SongCloud.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SongCloud
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,HSE_VALUE=8000000
  c include: .\RTE\Device\STM32F401RETx;$$Device:STM32F401RETx$Drivers\STM32F4xx_HAL_Driver\Inc;$$Device:STM32F401RETx$Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;$$Device:STM32F401RETx$Drivers\CMSIS\Device\ST\STM32F4xx\Include;$$Device:STM32F401RETx$Drivers\CMSIS\Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20002000 size 0x16000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group Flash OPT
    ./: STM32F401xx_OPT.s
  group Source Files
    ./: main.cpp
    ./RTE/Device/STM32F401RETx/: system_stm32f4xx.c
    $$Device:STM32F401RETx$Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:Startup 2.6.3
